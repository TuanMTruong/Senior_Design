* SPICE netlist aus sensor_2.sch
* 1/30/14 2:18 AM
***************************
*
*    Node  Net
*
*    0     GND
*    1     1.5V
*    2     5V
*    3     AGND
*    4     EN
*    5     G+
*    6     GND_PLANE
*    7     IN+
*    8     IN-
*    9     N$1
*   10     N$2
*   11     N$3
*   12     N$4
*   13     N$9
*   14     N$10
*   15     N$11
*   16     OUTPUT
*   17     REF
*   18     RESET+
*   19     RESET-
*
***************************

* C1
* PinOrder: 2
C1  15 43nF
* Warning: Not all of the Pins defined !

* C2
* PinOrder: 2
C2  13 100uF
* Warning: Not all of the Pins defined !

* C3
* PinOrder: 2
C3  3 150nF
* Warning: Not all of the Pins defined !

* C4
* PinOrder: 2
C4  3 100uF
* Warning: Not all of the Pins defined !

* C5
* PinOrder: 2
C5  14 10uF
* Warning: Not all of the Pins defined !

* C6
* PinOrder: 2
C6  3 0.1uF
* Warning: Not all of the Pins defined !

* C7
* PinOrder: 2
C7  3 0.1uF
* Warning: Not all of the Pins defined !

* IC1
IC1  7 8 -1 5 -2 -3 -4 -5 -6 -7 11 17 9 10 2 3 INA116U
* Warning: Unconnected Pins !

* IC3
IC3  4 14 13 15 LT6230LT6010(MOD12.2013)

* IC3B
IC3B  2 3 LT6230LT6010(MOD12.2013)

* JP1
JP1  6 3 M02PTH

* JP2
JP2  3 17 M02PTH

* JP3
JP3  2 4 M02PTH

* JP4
JP4  3 2 M02PTH

* JP5
* Part with only one Pin dropped

* R1
R1  15 13 38.3k

* R2
R2  12 1 2k

* R3
R3  16 15 10.5k

* R4
R4  11 8 80k

* R5
R5  18 5 60.4k

* R6
R6  19 18 20k

* R7
R7  10 9 1k

* R8
R8  14 1 20k

* R9
R9  1 2 14k

* R10
R10  3 1 6k

* SUPPLY1
* supply symbol dropped

* SUPPLY2
* supply symbol dropped

* SUPPLY3
* supply symbol dropped

* SUPPLY4
* supply symbol dropped

* SUPPLY5
* supply symbol dropped

* T1
T1  18 7 19 BC849SMD

* T2
T2  18 8 19 BC849SMD

* TP1
* Part with only one Pin dropped

* TP2
* Part with only one Pin dropped

* TP3
* Part with only one Pin dropped

.control
.endc

.end
